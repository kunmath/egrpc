SUMMARY = "egrpc — lightweight client-only gRPC C++ library for embedded Linux"
DESCRIPTION = "Clean-room, client-only gRPC C++ library wire-compatible with \
upstream gRPC servers. Code generated by upstream protoc + grpc_cpp_plugin \
compiles against egrpc unchanged. Runtime deps: nghttp2, OpenSSL, protobuf-lite."
HOMEPAGE = "https://github.com/egrpc/egrpc"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3537152baccbc83a7dc027e150de812b"

PV = "0.1.0+git"

EGRPC_SRC_URI ??= "git://github.com/egrpc/egrpc.git;protocol=https;branch=main"
SRCREV ??= "${AUTOREV}"
SRC_URI = "${EGRPC_SRC_URI}"
S = "${WORKDIR}/git"

DEPENDS = "nghttp2 openssl protobuf"

inherit cmake pkgconfig

EXTRA_OECMAKE = "-DEGRPC_BUILD_TESTS=OFF"

PACKAGECONFIG ??= ""
PACKAGECONFIG[examples] = "-DEGRPC_BUILD_EXAMPLES=ON,-DEGRPC_BUILD_EXAMPLES=OFF,protobuf-native egrpc-codegen-native"

# Regenerate the example stubs in-recipe instead of using the checked-in
# desktop copies: .pb.* with protobuf-native's protoc (must match the target
# protobuf runtime), .grpc.pb.* with the pinned egrpc-grpc_cpp_plugin v1.82.0.
do_configure:prepend() {
    if ${@bb.utils.contains('PACKAGECONFIG', 'examples', 'true', 'false', d)}; then
        gen=${S}/examples/route_guide/gen
        rm -f $gen/route_guide.pb.h $gen/route_guide.pb.cc \
              $gen/route_guide.grpc.pb.h $gen/route_guide.grpc.pb.cc
        ${STAGING_BINDIR_NATIVE}/protoc --version
        ${STAGING_BINDIR_NATIVE}/protoc \
            --proto_path=${S}/examples/route_guide \
            --cpp_out=$gen \
            --plugin=protoc-gen-grpc=${STAGING_BINDIR_NATIVE}/egrpc-grpc_cpp_plugin \
            --grpc_out=$gen \
            ${S}/examples/route_guide/route_guide.proto
    fi
}

do_install:append() {
    if ${@bb.utils.contains('PACKAGECONFIG', 'examples', 'true', 'false', d)}; then
        install -d ${D}${bindir}
        install -m 0755 ${B}/examples/route_guide/egrpc_route_guide_client ${D}${bindir}/
        install -m 0755 ${B}/examples/resilient_subscribe/egrpc_resilient_subscribe ${D}${bindir}/
    fi
}

PACKAGES =+ "${PN}-examples"
FILES:${PN}-examples = "${bindir}/egrpc_*"
